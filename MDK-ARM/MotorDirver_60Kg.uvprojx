# Keil uVision project MotorDirver_60Kg.uvprojx, settings and files
target MotorDirver_60Kg (6190000::V6.19::ARMCLANG)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3") TZ
  output: MotorDirver_60Kg +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=6 wLevel=3
  c define: USE_HAL_DRIVER,STM32F103xB,USE_FULL_LL_DRIVER
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../UserApp;../Ctrl/Sensor/Encoder;../Ctrl/Dirver;../Ctrl/Utils;../Ctrl/Sensors;../IQmath
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c adc.c can.c i2c.c spi.c tim.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_ll_rcc.c stm32f1xx_ll_utils.c stm32f1xx_ll_exti.c stm32f1xx_hal_can.c stm32f1xx_hal_i2c.c stm32f1xx_ll_spi.c stm32f1xx_ll_gpio.c stm32f1xx_ll_dma.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group UserApp
    ../UserApp/: user_main.c user_main.h
  group Dirver
    ../Ctrl/Dirver/: dirverFOC.c dirverFOC.h
  group common
    ../Ctrl/Utils/: lowpass_filter.c lowpass_filter.h pid.c pid.h foc_utils.c foc_utils.h getmicros.c getmicros.h
  group sensors
    ../Ctrl/Sensors/: sensors.h sensors.c
  group IQmath
    ../IQmath/rvmdk-cm3/: IQmathLib-cm3.lib
    ../IQmath/: IQmathLib.h
software components: CMSIS:CORE 5.6.0
